options:
  parameters:
    generate_options: qt_gui
    id: psk31
    output_language: python
  states: {}

blocks:
- name: doppler
  id: variable_qtgui_range
  parameters:
    label: Doppler
    orient: Qt.Horizontal
    start: '-10'
    step: '0.1'
    stop: '10'
    value: '-2'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-30'
    step: '0.1'
    stop: '30'
    value: '0'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '55'
  states: {}
- name: samp_per_sym
  id: variable
  parameters:
    value: int(samp_rate/31.25)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '125'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: float(samp_rate)/samp_per_sym
  states: {}
- name: test_string
  id: variable
  parameters:
    value: map(ord, 'The quick brown fox jumps over the lazy dog.\n')
  states: {}
- name: test_string_0
  id: variable
  parameters:
    value: bytes('The quick brown fox jumps over the lazy dog.\n', 'utf-8')
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /dev/stdout
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: '8000'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: test_string_0
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.001'
    freq_offset: 2*pi*freq_offset/samp_rate
    noise_voltage: 1.0e-3 * 10**(noise/20.0)
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    delays: (0.0,0.1,1.3)
    fDTs: 2*pi*10**doppler/samp_rate
    mags: (1,0.99,0.97)
    ntaps: '8'
    seed: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: psk31_coherent_demodulator_0
  id: psk31_coherent_demodulator
  parameters:
    agc_time_const: '8'
    costas_bandwidth: '0.15'
    samp_per_sym: samp_per_sym
    sync_bandwidth: '0.06'
    sync_phases: '32'
  states: {}
- name: psk31_constellation_decoder_0
  id: psk31_constellation_decoder
  parameters:
    differential_decode: 'True'
    varicode_decode: 'True'
  states: {}
- name: psk31_modulator_bc_0
  id: psk31_modulator_bc
  parameters:
    samp_per_sym: samp_per_sym
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '32'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate*8
    fc: '0'
    fftsize: '128'
    int_min: '-80'
    showports: 'True'
    type: complex
    update_time: '0'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: radioteletype_varicode_encode_bb_0
  id: radioteletype_varicode_encode_bb
  parameters: {}
  states: {}

connections:
- [blocks_throttle_0, '0', radioteletype_varicode_encode_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle_0, '0']
- [channels_channel_model_0, '0', psk31_coherent_demodulator_0, '0']
- [channels_channel_model_0, '0', qtgui_waterfall_sink_x_0, '0']
- [channels_selective_fading_model_0, '0', channels_channel_model_0, '0']
- [psk31_coherent_demodulator_0, '0', psk31_constellation_decoder_0, '0']
- [psk31_coherent_demodulator_0, '0', qtgui_const_sink_x_0, '0']
- [psk31_constellation_decoder_0, '0', blocks_file_sink_0, '0']
- [psk31_modulator_bc_0, '0', channels_selective_fading_model_0, '0']
- [radioteletype_varicode_encode_bb_0, '0', psk31_modulator_bc_0, '0']

metadata:
  file_format: 1
