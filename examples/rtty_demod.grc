options:
  parameters:
    generate_options: qt_gui
    id: rtty_demod
    output_language: python
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '45.45'
  states: {}
- name: center
  id: variable
  parameters:
    value: '2000'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '22'
  states: {}
- name: doppler
  id: variable_qtgui_range
  parameters:
    label: doppler
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    label: Frequency Offset
    orient: Qt.Horizontal
    start: '-0.02'
    step: '0.0001'
    stop: '.02'
    value: '0'
  states: {}
- name: mark
  id: variable
  parameters:
    value: center+spacing/2
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise
    orient: Qt.Horizontal
    start: '-20'
    step: '1'
    stop: '20'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: space
  id: variable
  parameters:
    value: center-spacing/2
  states: {}
- name: spacing
  id: variable
  parameters:
    value: '170'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: plughw:0
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1.0'
    high_cutoff_freq: samp_rate/2-200
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*1
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq_offset
    noise_voltage: 10**(noise/20)
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: channels_selective_fading_model_0
  id: channels_selective_fading_model
  parameters:
    LOS: 'False'
    N: '8'
    delays: (0.0,0.3,2.0)
    fDTs: doppler/samp_rate
    mags: (1,0.99,0.97)
    ntaps: '8'
    seed: '0'
  states: {}
- name: gr_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /dev/stdout
    type: byte
    unbuffered: 'True'
  states: {}
- name: gr_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: ./examples/rtty.wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: detector
    label2: mark
    label3: space
    nconnections: '3'
    size: int(samp_rate/decimation*10)
    srate: samp_rate/decimation
    type: float
  states: {}
- name: radioteletype_rtty_demod_cb_0
  id: radioteletype_rtty_demod_cb
  parameters:
    alpha: '0.35'
    baud: baud
    decimation: '1'
    mark_freq: mark
    samp_rate: samp_rate
    space_freq: space
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mark
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: space
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: detector
  states: {}
- name: virtual_sink_input
  id: virtual_sink
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: space
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: mark
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: detector
  states: {}
- name: virtual_source_8
  id: virtual_source
  parameters:
    stream_id: input
  states: {}
- name: virtual_source_8_0
  id: virtual_source
  parameters:
    stream_id: input
  states: {}

connections:
- [band_pass_filter_0, '0', virtual_sink_input, '0']
- [blocks_complex_to_float_0, '0', audio_sink_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [channels_channel_model_0, '0', channels_selective_fading_model_0, '0']
- [channels_selective_fading_model_0, '0', blocks_throttle_0, '0']
- [gr_wavfile_source_0, '0', hilbert_fc_0, '0']
- [hilbert_fc_0, '0', channels_channel_model_0, '0']
- [radioteletype_rtty_demod_cb_0, '0', gr_file_sink_0, '0']
- [radioteletype_rtty_demod_cb_0, '1', virtual_sink_0_1, '0']
- [radioteletype_rtty_demod_cb_0, '2', virtual_sink_0, '0']
- [radioteletype_rtty_demod_cb_0, '3', virtual_sink_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_sink_x_0, '2']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_8, '0', qtgui_sink_x_0, '0']
- [virtual_source_8, '0', radioteletype_rtty_demod_cb_0, '0']
- [virtual_source_8_0, '0', blocks_complex_to_float_0, '0']

metadata:
  file_format: 1
